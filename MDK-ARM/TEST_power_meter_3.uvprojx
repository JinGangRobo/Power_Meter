# Keil uVision project TEST_power_meter_3.uvprojx, settings and files
target TEST_power_meter_3 (6230000::V6.23::ARMCLANG)
  device: STM32C011F6Px STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: TEST_power_meter_3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32C011xx,KK_UI_REFRESH_MODE=0,KK_UI_NAV_DEPTH=4,KK_UI_EVENT_QUEUE_LENGTH=4,KK_UI_ENABLE_HOME=1,KK_UI_ENABLE_INFO=1,KK_UI_ENABLE_CUSTOM=1,KK_UI_ENABLE_INT_EDITOR=0,KK_UI_ENABLE_BOOL_EDITOR=0,KK_UI_ENABLE_CONFIRM=0,KK_UI_ENABLE_MESSAGE=0,KK_UI_ENABLE_TOAST=0,KK_UI_ENABLE_DRAW_HELPERS=1
  c misc: -Oz
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;../User/Inc;../User/ThirdParty/KK_OLED/include;../User/ThirdParty/KK_OLED/graphics;../User/ThirdParty/KK_OLED/driver;../User/ThirdParty/KK_UI/include;../User/ThirdParty/KK_UI/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32c011xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group User
    ../User/Inc/: app.h ina228.h key.h led.h kk_pm_font.h public_config.h kk_pm_ui.h kk_pm_icons.h kk_pm_splash.h
    ../User/Src/: led.c key.c ina228.c app.c esc.c kk_pm_font.c kk_pm_ui.c kk_pm_splash.c
  group KK_UI
    ../User/ThirdParty/KK_UI/src/: kk_ui.c kk_ui_anim.c kk_ui_dialog.c kk_ui_draw.c kk_ui_home.c kk_ui_menu.c kk_ui_nav.c kk_ui_page.c kk_ui_internal.h
    ../User/ThirdParty/KK_UI/include/: kk_ui.h kk_ui_config.h kk_ui_draw.h
  group KK_OLED
    ../User/ThirdParty/KK_OLED/graphics/: kk_oled.c kk_oled_draw.c kk_oled_font.c kk_oled_bitmap.c kk_oled_internal.h
    ../User/ThirdParty/KK_OLED/driver/: kk_oled_driver.c kk_oled_driver.h
    ../User/ThirdParty/KK_OLED/include/: kk_oled.h
software components: CMSIS:CORE 6.1.0
